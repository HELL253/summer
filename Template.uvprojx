# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group TASK
    ../TASK/: motor_control_task.c line_location_collect_task.c oled_show_task.c bluetooth_serial_task.c
  group HARDWARE
    ../HARDWARE/: led.c led.h OLED.c OLED.h OLED_Font.h motor.c motor.h grayscale_sensor.c grayscale_sensor.h spl_i2c.c spl_i2c.h Key.c Key.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/: adc.c adc.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c
  group FWLIB
    ../FreeRTOS/: timers.c
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../: README.txt
